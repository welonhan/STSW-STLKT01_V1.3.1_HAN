# IAR project Project.ewp, settings and files
configuration STM32L476JG-SensorTile (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476JG ST STM32L476JG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_USB_FS; BLUENRG_MS; BLUENRG_DESIRED_FW_VERSION=0x0715
  ICCARM.CCIncludePath2: ..\Inc; ..\Inc\BlueNRG; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsm; ..\..\..\..\..\Drivers\BSP\Components\lps25hb; ..\..\..\..\..\Drivers\BSP\Components\lsm6ds3; ..\..\..\..\..\Drivers\BSP\Components\lis3mdl; ..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\Drivers\BSP\Components\pcm1774; ..\..\..\..\..\Drivers\BSP\SensorTile; ..\..\..\..\..\Drivers\BSP\SensorTile_MB; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO_CDC\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\Drivers\BSP\Components\lps22hb; ..\..\..\..\..\Drivers\BSP\Components\lsm303agr; ..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AudioLoop.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/pcm1774/: PCM1774_CODEC_Driver.c
  group Drivers/BSP/SensorTile
    ../../../../../Drivers/BSP/SensorTile/: SensorTile.c SensorTile_audio_in.c SensorTile_audio_out.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_usb.c
  group Example/EWARM
    ./: startup_stm32l476xx.s
  group Example/User
    ../Src/: cube_hal_l4.c main.c stm32l4xx_hal_msp.c stm32l4xx_it.c usbd_audio_if.c usbd_conf_l4.c usbd_desc.c
  group Middlewares/STM32_USB_Device_Library
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio_in.c
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
